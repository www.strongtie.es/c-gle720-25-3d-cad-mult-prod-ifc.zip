Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-10-12T14:41:24
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Oct 12 14:41:24 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{C386E982-3AC1-47B2-AC4D-643E0530B43A}\ifc * Database version: 5507 * Database creation date: Thu Oct 12 14:41:24 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Oct 12 14:41:24 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Oct 12 14:41:24 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-234032 BIMCAD EU_Batch 2_1253 models\Working\3D Content\Part 2 - 250 Models\Normal Holes\RFA 3D\C_GLE720_194_25_3D_CAD_MULT_Prod.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Identity Data - Name: Level 1; Building Story: yes; Structural: no
Dimensions - Computation Height: 0 mm
Graphics - Line Weight: 1; Line Pattern: -3000010; Color: 0; Symbol at End 2 Default: yes; Symbol at End 1 Default: no

# IfcBuildingElementProxy: C_GLE720_194_25_3D_CAD_MULT_Prod, C_GLE720_194_25_3D_CAD_MULT_Prod:C_GLE720_194_25_3D_CAD_MULT_Prod:103786
In: Level 1
Material: Galvanised
Dimensions - Volume: 0.00565617 ft3
Other - Schedule Level: Level: Level 1
Phasing - Phase Created: New Construction
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GLE720/194/2.5
Identity Data - Name: GLE720/194/2.5; Copyright: ©Simpson Strong-Tie; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; Model: GLE720/194/2.5; UniClass Title: Joist hangers; Model ID: 0326302774947805223383970503904738321621; ObjectType: GLE720/194/2.5; UniClass Number: Pr_20_29_31_44; Provide Feedback: mailto:EUdrawings@strongtie.com; OmniClass Title: Wood Connectors; Description: Joist hanger; Product Type: Joist hanger; OmniClass Number: 23.20.40.11.24.14; URL: www.strongtie.eu; Manufacturer: Simpson Strong-Tie
General - Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets; Density: 1.181; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; Reference: GLE720/194/2.5; EPD: https://www.strongtie.eu/eu-EU/EPD
Materials and Finishes - Product Material: Galvanised
