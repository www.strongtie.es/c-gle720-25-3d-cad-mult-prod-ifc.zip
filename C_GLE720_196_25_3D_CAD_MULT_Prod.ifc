Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-10-12T14:41:25
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Oct 12 14:41:25 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{D7C7ADCD-2C1A-4971-987E-52090E18D7DA}\ifc * Database version: 5507 * Database creation date: Thu Oct 12 14:41:24 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Oct 12 14:41:25 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Oct 12 14:41:25 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-234032 BIMCAD EU_Batch 2_1253 models\Working\3D Content\Part 2 - 250 Models\Normal Holes\RFA 3D\C_GLE720_196_25_3D_CAD_MULT_Prod.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Identity Data - Name: Level 1; Structural: no; Building Story: yes
Dimensions - Computation Height: 0 mm
Graphics - Symbol at End 1 Default: no; Symbol at End 2 Default: yes; Line Pattern: -3000010; Line Weight: 1; Color: 0

# IfcBuildingElementProxy: C_GLE720_196_25_3D_CAD_MULT_Prod, C_GLE720_196_25_3D_CAD_MULT_Prod:C_GLE720_196_25_3D_CAD_MULT_Prod:104414
In: Level 1
Material: Galvanised
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Dimensions - Volume: 0.00565617 ft3
Other - Schedule Level: Level: Level 1
Phasing - Phase Created: New Construction
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GLE720/196/2.5
Identity Data - Product Type: Joist hanger; Model: GLE720/196/2.5; Manufacturer: Simpson Strong-Tie; ObjectType: GLE720/196/2.5; UniClass Number: Pr_20_29_31_44; Description: Joist hanger; OmniClass Number: 23.20.40.11.24.14; OmniClass Title: Wood Connectors; Name: GLE720/196/2.5; UniClass Title: Joist hangers; Provide Feedback: mailto:EUdrawings@strongtie.com; Copyright: ©Simpson Strong-Tie; Model ID: 0326302774947805223383970503904738321621; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; URL: www.strongtie.eu
General - Reference: GLE720/196/2.5; Density: 1.181; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets; EPD: https://www.strongtie.eu/eu-EU/EPD
Materials and Finishes - Product Material: Galvanised
